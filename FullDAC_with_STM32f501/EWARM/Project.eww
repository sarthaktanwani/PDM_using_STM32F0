<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FullDAC_with_STM32f501.ewp</path>
  </project>
  <batchBuild />
</workspace>
