<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PDM_with_stm32f030.ewp</path>
  </project>
  <batchBuild />
</workspace>
